# Keil uVision project RobotArmControl.uvprojx, settings and files
target RobotArm_Vision_Sort (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: robot_arm_control +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB
  c misc: --diag_warning=1
  c include: ..\App;..\Protocol;..\Calibration;..\Vision;..\Display;..\Drivers\CMSIS\Include;..\Drivers\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../App/: main.c board_config.h
  group Startup
    ../Core/: startup_stm32f10x_md.s system_clock.c
  group Motor core
    ../Protocol/: motor_control.c motor_control.h
  group Coordinate calibration
    ../Calibration/: calibration.c calibration.h model_data.h
  group Automatic pick and place
    ../Protocol/: pick_cycle.c pick_cycle.h pick_config.h
  group Vision and batch control
    ../Vision/: vision_protocol.c pixel_map.c robot_control.c vision_config.h robot_control.h
  group Smooth motion
    ../Protocol/: motion_profile.c motion_profile.h
  group Single screen SSD1306
    ../Display/: robot_display.c oled_ssd1306.c robot_display.h
